# IAR project actuator.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L110C6PA HDSC HC32L110C6PA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\application; ..\public\drive\inc; ..\public\startup; ..\public; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: testPrj3.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\HDSC\HC32L110B6_C6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\application; ..\..\public\drive\inc; ..\..\public\startup; ..\..\public; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: rt1_23wifi.bin
  ILINK.IlinkIcfFile: hc32l136_bootlaod.icf
  group application
    ../application/: app_backlight.c app_backlight.h app_cfg.h app_main.c interrupts_hc32l110.c interrupts_hc32l110.h
  group module/mod_led
    ../module/mod_led/: mod_led.c mod_led.h
  group module/mod_led/depend
    ../module/mod_led/depend/: bsp_led.c bsp_led.h
  group module/mod_ntc
    ../module/mod_ntc/: mod_ntc.c mod_ntc.h
  group module/mod_ntc/depend
    ../module/mod_ntc/depend/: bsp_ntc.c bsp_ntc.h
  group module/mod_system_clock
    ../module/mod_system_clock/: mod_system_clock.c mod_system_clock.h
  group module/mod_system_clock/depend
    ../module/mod_system_clock/depend/: bsp_system_clock.c bsp_system_clock.h
  group module/mod_system_tick
    ../module/mod_system_tick/: mod_system_tick.c mod_system_tick.h
  group module/mod_system_tick/depend
    ../module/mod_system_tick/depend/: bsp_system_tick.c bsp_system_tick.h
  group public
    ../public/: base_types.h ddl_device.h HC32L110.h system_hc32l110.c system_hc32l110.h
  group public/drive
    ../public/drive/src/: adc.c clk.c ddl.c flash.c gpio.c
    ../public/drive/inc/: adc.h clk.h ddl.h flash.h gpio.h
  group public/startup
    ../public/startup/: startup_hc32l110.s
